# Keil uVision project remote.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: remote +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\CMSIS;..\System;..\User;..\HardWareDriver\C;..\HardWareDriver\H;..\Lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group Lib
    ../Lib/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c
  group User
    ../User/: main.c
  group System
    ../System/: sys.c spi.c delay.c
  group HardWareDrive
    ../HardWareDriver/C/: adc.c Led.c NRF24L01.c stmflash.c Tim.c Display.c Key.c
    ../System/: usart.c
