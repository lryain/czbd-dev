# Keil uVision project radio_tx.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: radio_tx
  c flags: Optim=1
  c include: ..\project_nrf51\Basic\Include_H;..\project_nrf51\Peripherals\boards;..\project_nrf51\Basic\startup;..\project_nrf51\Basic\Include_C\nrf_radio;..\out
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ../project_nrf51/Basic/startup/: arm_startup_nrf51.s project_nrf51822.c system_nrf51.c
  group 用户
    ../out/: radio_tx.c pm.c
    ../project_nrf51/Basic/Include_C/nrf_delay/: nrf_delay.c
  group 内设
    ../project_nrf51/Basic/Include_C/: nrf_gpio.c
    ../project_nrf51/Basic/Include_C/nrf_radio/: radio_config.c
    ../project_nrf51/Basic/Include_C/nrf_delay/: nrf_delay.c
    ../project_nrf51/Basic/Include_C/simple_uart/: simple_uart.c
    ../out/: nrf_adc.c
  group 外设
    ../project_nrf51/Peripherals/boards/: pca10001.h
