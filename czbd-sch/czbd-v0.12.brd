# Repository lryain/czbd-dev

## EAGLE design czbd-sch/czbd-v0.12.brd

Parts:
16M: 16MHz; RESONATOR-SMD
ATMEL32U4: ATMEGA32U4QFN; SPARKFUN-DIGITALIC_QFN-44
BMP180: BMP180
BT4.0: BLE-4.0; HEXAIRBOT-HEXNANO_BLUETOOTH_HM11
C1: 1uF; 0402-CAP
C2: 0.1uF; 0402-CAP
C3: 2.2nF; 0402-CAP
C4, C5, C11, C12, C13: 100nF; 0402-CAP
C6: 2.2uF; 0402-CAP
C7: 10uF; 0402-CAP
C8, C17: 10uF; 0805
C9: 220nF; 0402-CAP
C10: 4.7uF; 0402-CAP
CHG: Yellow; CHIPLED_0603
D1: LED-ARGB-4P-1206; LED-4P-1206-3.0X1.5
HMC5883: HMC5883LSMD; 16LPCC
IC4: MCP73831; SOT23-5
J1: USB-MINI; USB_MICRO
J4: CONNECTOR_HEADER-2X3P-2.0; CONNECTOR_2X3P-2.0
JP1, JP3, JP5, JP7, JP10, JP11, JP12, JP13: M01PTH_2MM; 1X01_2MM
LED4, LED5: F_R_Green; CHIPLED_0603
LED6, LED7: RED; CHIPLED_0603
MCU6050: MPU6050; TESTING_QFN-24-4MM2
P1, P2: V1; 1X01
PWR: F_R_Green; CHIPLED_0603
R1, R4, R9, R11, R13, R15, R17, R24, R28: 10K; 0402-RES
R2, R3: 22R; 0402-RES
R5, R6: 4K7; 0402-RES
R7, R23, R26: 1.5K; 0402-RES
R8, R19, R20, R21, R22, R27, R30: 1K; 0402-RES
R10, R12, R14, R16, R18: 330; 0402-RES
R29: 2K; 0402-RES
SW2: SWITCH-3P-SMD-6.6X2.8; 3P-SMD-2CH-6.6X2.8-REINFORCE
T1, T2, T3, T4, T5: IRLML2502; SOT-23
T7: FDN340P; SOT23
TXD: F_L_Green; CHIPLED_0603
U3: LTC3200-5SOT; SOT23-6
U4: MIC5205-3.3BM5; SOT23-5
U7: LMV321M5; SOT23-5
Z1, Z2: CG0603MLC-05E; CT/CN0603

Connections:
3.3V: BMP180.2 (VCC), BMP180.3 (VCCIO), BT4.0.9 (VCC), C5.2, C12.1, C13.1, HMC5883.2 (VDD), HMC5883.4 (S1), HMC5883.13 (VDDIO), MCU6050.8 (VLOGIC), MCU6050.13 (VDD), R5.2, R6.2, U4.5 (OUT), U7.3 (-IN)
3.7V: C8.2, JP1.1, JP3.1, JP5.1, JP7.1, LED4.A, LED5.A, LED6.A, LED7.A, R21.2, R27.2, SW2.A, U3.3 (!SHDN), U3.5 (VIN), U7.1 (+IN)
5V: ATMEL32U4.14 (VCC), ATMEL32U4.24 (AVCC), ATMEL32U4.34 (VCC), ATMEL32U4.44 (AVCC), C7.1, D1.2 (+), J4.6, R4.2, R8.2, T7.2 (S), U3.1 (VOUT), U4.1 (IN), U4.3 (EN), U7.5 (V+)
A0: ATMEL32U4.36 (PF7(ADC7)), R27.1, R28.2
A1: ATMEL32U4.37 (PF6(ADC6))
A2: ATMEL32U4.38 (PF5(ADC5))
A3: ATMEL32U4.39 (PF4(ADC4))
A4: ATMEL32U4.40 (PF1(ADC1))
A5: ATMEL32U4.41 (PF0(ADC0))
D4: ATMEL32U4.25 (PD4(ADC8)), R17.1, R18.1
D5: ATMEL32U4.31 (PC6), R13.1, R14.1
D6: ATMEL32U4.27 (PD7(ADC10)), R9.1, R10.1
D7: ATMEL32U4.1 (PE6), R7.1
D8: ATMEL32U4.28 (PB4(ADC11)), R23.1
D9: ATMEL32U4.29 (PB5(ADC12)), R15.1, R16.1
D10: ATMEL32U4.30 (PB6(ADC13)), R11.1, R12.1
D11: ATMEL32U4.12 (PB7)
D12: ATMEL32U4.26 (PD6(ADC9))
D13: ATMEL32U4.32 (PC7)
D+: J1.P3 (D+), R2.1, Z2.1
D-: J1.P2 (D-), R3.1, Z1.1
GND: 16M.2, ATMEL32U4.5 (UGND), ATMEL32U4.15 (GND), ATMEL32U4.23 (GND), ATMEL32U4.35 (GND), ATMEL32U4.43 (GND), BMP180.7 (GND), BT4.0.12 (GND), C1.1, C2.1, C3.2, C4.2, C5.1, C7.2, C8.1, C10.2, C11.2, C12.2, C13.2, C17.1, HMC5883.9 (GND), HMC5883.11 (GND), IC4.2 (VSS), J1.P5 (GND), J1.P$1 (SH7), J1.P$2 (SH8), J1.P$3 (SH9), J1.P$4 (SH10), J1.P$5 (SH11), J1.P$6 (SH12), J1.P$7 (SH13), J1.P$8 (SH14), J1.S1 (SH1), J1.S2 (SH2), J1.S3 (SH3), J1.S4 (SH4), J1.S5 (SH5), J1.S6 (SH6), J4.4, MCU6050.1 (CLKIN), MCU6050.9 (AD0), MCU6050.11 (FSYNC), MCU6050.18 (GND), P1.1, PWR.C, R1.1, R9.2, R11.2, R13.2, R15.2, R17.2, R22.1, R24.1, R28.1, T1.2 (S), T2.2 (S), T3.2 (S), T4.2 (S), T5.2 (S), U3.2 (GND), U4.2 (GND), U7.2 (V-), Z1.2, Z2.2
MISO: ATMEL32U4.11 (PB3(MISO)), J4.1
MOSI: ATMEL32U4.10 (PB2(MOSI)), J4.5
unnamed: 16M.1, ATMEL32U4.17 (XTAL1)
unnamed: 16M.3, ATMEL32U4.16 (XTAL2)
unnamed: CHG.C, IC4.1 (STAT)
unnamed: CHG.A, R20.1
unnamed: ATMEL32U4.6 (UCAP), C1.2
unnamed: ATMEL32U4.42 (AREF), C2.2
unnamed: R8.1, TXD.A
unnamed: C4.1, MCU6050.10 (REGOUT)
unnamed: C3.1, MCU6050.20 (CPOUT)
unnamed: D1.1 (B), R29.2
unnamed: ATMEL32U4.33 (PE2/!HWB), R1.2
unnamed: R18.2, T5.3 (G)
unnamed: PWR.A, R21.1
unnamed: R12.2, T2.3 (G)
unnamed: R10.2, T1.3 (G)
unnamed: JP11.1, T1.1 (D)
unnamed: JP10.1, T2.1 (D)
unnamed: R14.2, T3.3 (G)
unnamed: JP13.1, T3.1 (D)
unnamed: R16.2, T4.3 (G)
unnamed: JP12.1, T4.1 (D)
unnamed: R19.1, R30.1, T5.1 (D)
unnamed: C9.1, HMC5883.8 (SETP)
unnamed: LED4.C, LED5.C, R19.2
unnamed: C6.1, U3.6 (C+)
unnamed: IC4.5 (PROG), R22.2
unnamed: C6.2, U3.4 (C-)
unnamed: C9.2, HMC5883.12 (SETC)
unnamed: C10.1, HMC5883.10 (C1)
unnamed: P2.1, SW2.COM
unnamed: C11.1, U4.4 (BP)
unnamed: D1.4 (R), R23.2
unnamed: D1.3 (G), R7.2
unnamed: R24.2, T7.3 (G), U7.4 (OUT)
unnamed: BT4.0.4 (RX), R26.2
unnamed: LED6.C, LED7.C, R30.2
RESET: ATMEL32U4.13 (!RESET), J4.3, R4.1
RX: ATMEL32U4.20 (PD2(RX)), BT4.0.2 (TX)
RXLED: ATMEL32U4.8 (PB0(SS))
SCK: ATMEL32U4.9 (PB1(SCK)), J4.2, R29.1
SCL: ATMEL32U4.18 (PD0(SCL)), BMP180.5 (SCL), HMC5883.1 (SCL), MCU6050.23 (SCL), R6.1
SDA: ATMEL32U4.19 (PD1(SDA)), BMP180.6 (SDA), HMC5883.16 (SDA), MCU6050.24 (SDA), R5.1
TX: ATMEL32U4.21 (PD3(TX)), R26.1
TXLED: ATMEL32U4.22 (PD5), TXD.C
USBD+: ATMEL32U4.4 (D+), R2.2
USBD-: ATMEL32U4.3 (D-), R3.2
VCC: IC4.3 (VBAT), SW2.B
VUSB: ATMEL32U4.2 (UVCC), ATMEL32U4.7 (VBUS), C17.2, IC4.4 (VIN), J1.P1 (VBUS), R20.2, T7.1 (D)

Notes on the sheet:
not in use

Board: 2 copper layers, 77.0 x 77.0 mm, 85 parts (20 on the bottom side), 63 nets.

Other parts of the board:
U$2: DUINOFUN-LOGO-PCB-0.4
U$3: MINI-4-ZOU+48
U$4: DUINOPEAK-LOGO-0.6

## EAGLE design czbd-sch/czbd-rc-v0.11 - bk.brd

Parts:
ANT2: ANTENNA-SMA-EDGE; 3P-SMA-EDGE
BAT1: HEADER-2P-2.54; 2P-2.54-DIP
BG1, BG2: ledBG; D1206
C1, C2, C3, C4, C6, C10, C11, C15, C17, C18, C22: 100nF; DISCRETE_C0603
C5: 2.2nF; DISCRETE_C0603
C7, C21: 10uF; DISCRETE_C0805
C8, C9: 220uF; ELECTRO-5.3MM
C12, C13: 22pF; 0603
C14: 100nF; 0603
C16, C19, C23, C24: 1uF; DISCRETE_C0603
C20: 220nF; DISCRETE_C0603
C25: 10uF; DISCRETE_C0603
C26: 2.2uF; DISCRETE_C0603
CH1: CH; D0805
D3: 1N4148; DISCRETE_SOD323
DC1, DC2: DC-18650; DC18650B
F1: 1A; PTC-1206
J1, J2: HEADER-4P-2.54; 4P-2.54-DIP
J3: USB-MINI; USB_MICRO
JP1: M01PTH; 1X01
LED: DC; D0805
OK1: OK; D0805
OK2: LED5; D0805
OK3: LED4; D0805
OK4: LED2; D0805
OK5: LED3; D0805
OK6: LED1; D0805
R1, R2, R3, R4, R9, R16: 1k; DISCRETE_R0603
R5, R6, R7, R8, R17, R18, R20, R21, R29, R30, R31, R35: 10k; DISCRETE_R0603
R10, R11, R13, R14, R15, R23, R24, R25, R26, R27, R42, R55, R64: 1k; R0603
R12: 240; R0603
R19: 1M; DISCRETE_R0603
R22: 470K; DISCRETE_R0603
R43, R63: 10k; R0603
R49: 10K; R0603
RXD: RXD; D0805
SJ1, SJ2, SJ3, SJ4, SJ5: LO; SPARKFUN_SJ_2S-TRACE
SP1: F/PMX04; F/PMX04A
SW1: SEEEDSTUDIO-DISCRETE.RPT_SWITCH-2CH-6P; SEEEDSTUDIO-DISCRETE.RPT_6P-2CH-2.54-7.6X3.0
TXD: TXD; D0805
U1: CH340G; SO16
U2: TP4056; SOP8+1
U3: MPU6050; TESTING_QFN-24-4MM2
U4, U6: 662K; SOT23-3
U5: OLED12864; UG-2864HSWEG01_0.96IN_WRAPAROUND
U7: SI2301; ARDUINO-QXZ_SI2301
U8: OLED-TK; OLED-0.96C-TK
U10: STC15W4KxxS4; LQFP44
U$5: NRF24L01+PA1; NRF24L01+PA-C
U$8, U$23: TRIMPOT-7P; TO-5P
U$11: NRF24L01; SI24R01-B
U$27: LCD9648A; LCD96X48
WS1, WS2, WS3, WS4: SW; TACTILE-SWITCH-1101NE
WSA: SW; TACTILE-SWITCH-1101NE
WSB: SW; TACTILE-SWITCH-1101NE
WSC: SW; TACTILE-SWITCH-1101NE
WSD: SW; TACTILE-SWITCH-1101NE
WSL: SWITCH-4PS; B3F-31XX
WSR: SWITCH-4PS; B3F-31XX
X1: 12M; TC26H
Y1, Y2: YAOGAN; YAOGAN5K

Connections:
3.3V: BG1.+, BG2.+, C8.+, C18.2, J1.2, J2.3, OK2.+, OK3.+, OK4.+, OK5.+, OK6.+, R49.2, U5.6 (VBAT), U5.9 (VDD), U6.2 (V3.3V), U7.2 (S), U$5.1 (VCC), U$11.2 (VCC), U$27.P8 (VCC)
3.7V: C21.2, C22.2, R63.1, R64.2, SW1.CH1B, SW1.CH2B, U4.3 (VIN), U6.3 (VIN)
ADC1: C1.1, R1.1, U10.4 (P1.0/ADC0/RXD2)
ADC2: C2.1, R2.1, U10.5 (P1.1/ADC1/TXD1)
ADC3: C3.1, R3.1, U10.7 (P1.2/ADC2/SS/ECI/CMPO)
ADC4: C4.1, R4.1, U10.8 (P1.3/ADC3/MOSI)
ADC5: C11.1, R9.1, U10.9 (P1.4/ADC4/MISO)
ADC6: C15.1, R16.1, U10.10 (P1.5/ADC5/SCLK)
ADC7: J2.2, U10.12 (P1.7/ADC7/TXD3/XT/PWM7)
ADCV: J2.1, R43.2, R63.2, U10.11 (P1.6/ADC6/RXD3/XT/PWM6)
BAT: BAT1.1, DC1.+, DC2.+, SW1.CH1A, SW1.CH2A, SW1.COM1, SW1.COM2, U2.5 (BAT)
CE: U10.30 (P2.0), U$5.2 (CE), U$11.3 (CE)
CHRG2: R15.1, U2.7 (!CHRG)
FMQ: R55.1, U10.13 (P5.4/MCLKO/SS_3/CMP-)
GND: ANT2.GND@0 (GND), ANT2.GND@1 (GND), ANT2.GND@2 (GND), ANT2.GND@3 (GND), BAT1.2, C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, C7.1, C8.-, C9.-, C10.2, C11.2, C12.1, C13.1, C14.1, C15.2, C17.1, C18.1, C20.2, C21.1, C22.1, C25.1, C26.1, DC1.-, DC2.-, J1.1, J2.4, J3.P5 (GND), J3.P$1 (SH7), J3.P$2 (SH8), J3.P$3 (SH9), J3.P$4 (SH10), J3.P$5 (SH11), J3.P$6 (SH12), J3.P$7 (SH13), J3.P$8 (SH14), J3.S1 (SH1), J3.S2 (SH2), J3.S3 (SH3), J3.S4 (SH4), J3.S5 (SH5), J3.S6 (SH6), LED.-, R13.1, R19.2, R22.1, R43.1, SP1.- (1), U1.1 (GND), U2.1 (TEMP), U2.3 (GND), U2.9 (GND1), U3.1 (CLKIN), U3.9 (AD0), U3.11 (FSYNC), U3.18 (GND), U4.1 (GND), U5.1 (NC(GND)), U5.8 (VSS), U5.10 (BS0), U5.11 (BS1), U5.12 (BS2), U5.29 (VLSS), U5.30 (NC(GND)), U6.1 (GND), U10.16 (GND), U$5.8 (GND), U$8.1 (L), U$8.6 (G1), U$8.7 (G2), U$11.1 (GND), U$23.1 (L), U$23.6 (G1), U$23.7 (G2), U$27.P5 (NC1), U$27.P7 (GND1), U$27.P11 (GND2), U$27.P15 (GND3), U$27.P16 (NC2), U$27.P17 (NC3), WS1.P$2 (2), WS2.P$2 (2), WS3.P$2 (2), WS4.P$2 (2), WSA.P$2 (2), WSB.P$2 (2), WSC.P$2 (2), WSD.P$2 (2), WSL.1 (S), WSL.3 (G2), WSL.4 (G1), WSR.1 (S), WSR.3 (G2), WSR.4 (G1), Y1.H3 (H-), Y1.MOUNT1 (G1), Y1.MOUNT2 (G2), Y1.MOUNT3 (G3), Y1.MOUNT4 (G4), Y1.V3 (V-), Y2.H3 (H-), Y2.MOUNT1 (G1), Y2.MOUNT2 (G2), Y2.MOUNT3 (G3), Y2.MOUNT4 (G4), Y2.V3 (V-)
IRQ: U10.20 (P3.2/INT0), U$5.7 (IRQ), U$11.8 (IRQ)
LCD_A0: SJ3.1, U10.38 (PWM3_2/ALE/P4.5), U$27.P12 (A0)
LCD_BG: R25.1, U10.25 (PWM2/TXD_2/INT3/P3.7)
LCD_CS: SJ1.1, U10.35 (CCP0_3/P2.5), U$27.P14 (CS)
LCD_RST: SJ2.1, U10.40 (RXD3/P0.0), U$27.P13 (RESET)
LCD_SCK: SJ4.1, U10.37 (PWM2_2/CCP2_3/P2.7), U$27.P10 (SCK)
LCD_SDA: SJ5.1, U10.36 (CCP1_3/P2.6), U$27.P9 (SDA)
LED1: R27.1, U10.1 (P0.5/T3/PWMFLT_2)
LED2: R24.1, U10.2 (P0.6/T4CLKO/PWM7_2)
LED3: R26.1, U10.3 (P0.7/T4/PWM6_2)
LED4: R23.1, U10.17 (P4.0/MOSI_3)
LED5: R42.1, U10.15 (P5.5/CMP+)
MISO: U10.32 (PWM4/MISO_2/P2.2), U$5.6 (MISO), U$11.7 (MISO)
MOSI: U10.33 (PWM5/MOSI_2/P2.3), U$5.5 (MOSI), U$11.6 (MOSI)
unnamed: R1.2, Y1.H2 (H)
unnamed: R3.2, Y2.H2 (H)
unnamed: R4.2, Y2.V2 (V)
unnamed: R2.2, Y1.V2 (V)
unnamed: R9.2, U$23.2 (W2), U$23.3 (W1)
unnamed: R16.2, U$8.2 (W2), U$8.3 (W1)
unnamed: C16.1, U$27.P1 (VB1+)
unnamed: C16.2, U$27.P2 (VB1-)
unnamed: C19.1, U$27.P3 (VB0+)
unnamed: C19.2, U$27.P4 (VB0-)
unnamed: C20.1, R19.1, U$27.P6 (VLCD)
unnamed: OK3.-, R23.2
unnamed: OK4.-, R24.2
unnamed: R22.2, U5.26 (IREF)
unnamed: CH1.-, R15.2
unnamed: C10.1, U3.10 (REGOUT)
unnamed: C5.1, U3.20 (CPOUT)
unnamed: C23.2, U5.2 (C2P)
unnamed: C23.1, U5.3 (C2N)
unnamed: OK6.-, R27.2
unnamed: ANT2.SIG (SIGNAL), JP1.1
unnamed: R13.2, U2.2 (PROG)
unnamed: SP1.+ (2), U7.1 (D)
unnamed: C24.2, U5.4 (C1P)
unnamed: C24.1, U5.5 (C1N)
unnamed: OK2.-, R42.2
unnamed: C25.2, U5.28 (VCC)
unnamed: D3.-, U1.2 (TXD)
unnamed: C26.2, U5.27 (VCOMH)
unnamed: BG1.-, BG2.-, R25.2
unnamed: OK5.-, R26.2
unnamed: R10.1, TXD.+
unnamed: R49.1, R55.2, U7.3 (G)
unnamed: R11.1, RXD.+
unnamed: C13.2, U1.8 (XO), X1.1
unnamed: C12.2, U1.7 (XI), X1.2
unnamed: F1.2, J3.P1 (VBUS)
unnamed: C14.2, U1.4 (V3)
unnamed: R12.2, U1.3 (RXD)
unnamed: J3.P2 (D-), U1.6 (UD-)
unnamed: J3.P3 (D+), U1.5 (UD+)
unnamed: LED.+, R64.1
unnamed: OK1.-, R14.2
OLED_CS: SJ5.2, U5.13 (/CS)
OLED_DC: SJ3.2, U5.15 (DC/I2C_SA0)
OLED_RES: SJ4.2, U5.14 (/RES)
OLED_SCLK: SJ2.2, U5.18 (D0/SPI_SCLK/I2C_SCK)
OLED_SDIN: SJ1.2, U5.19 (D1/SPI_SDIN/I2C_SDA)
RXD1: D3.+, RXD.-, U10.18 (P3.0/RXD)
RXD2: J1.4, U10.39 (RXD2_2/P4.6)
SCL: R35.2, U3.23 (SCL), U10.41 (TXD3/P0.1)
SCLK: U10.31 (PWM3/SCLK_2/P2.1), U$5.4 (SCK), U$11.5 (SCK)
SCN: U10.34 (ECI_3/SS_2/PWMFLT/P2.4), U$5.3 (SCN), U$11.4 (SCN)
SDA: R30.2, U3.24 (SDA), U10.42 (RXD4/P0.2)
STCV: C6.2, C9.+, C17.2, R5.1, R6.1, R7.1, R8.1, R17.1, R18.1, R20.1, R21.1, R29.1, R30.1, R31.1, R35.1, U3.8 (VLOGIC), U3.13 (VDD), U4.2 (V3.3V), U10.14 (VCC), U$8.4 (H1), U$8.5 (H2), U$23.4 (H1), U$23.5 (H2), Y1.H1 (H+), Y1.V1 (V+), Y2.H1 (H+), Y2.V1 (V+)
STDBY2: R14.1, U2.6 (!STDBY)
TXD1: R12.1, TXD.-, U10.19 (P3.1/TXD)
TXD2: J1.3, U10.6 (P4.7/TXD2_2)
USBV: C7.2, CH1.+, F1.1, OK1.+, R10.2, R11.2, U1.16 (VCC), U2.4 (VCC), U2.8 (CE)
WS1: R5.2, U10.26 (MISO_3/P4.1), WS1.P$1 (1)
WS2: R6.2, U10.28 (SCLK_3/P4.3), WS2.P$1 (1)
WS3: R7.2, U10.27 (PWM5_2/WR/P4.2), WS3.P$1 (1)
WS4: R8.2, U10.29 (PWM4_2/RD/P4.4), WS4.P$1 (1)
WSA: R20.2, U10.21 (P3.3/INT1), WSA.P$1 (1)
WSB: R21.2, U10.22 (P3.4/ECI_2/T0/T1CLKO), WSB.P$1 (1)
WSC: R29.2, U10.23 (CCP0_2/T1/T0CLKO/P3.5), WSC.P$1 (1)
WSD: R31.2, U10.24 (CCP1_2/RXD_2/INT2/P3.6), WSD.P$1 (1)
WSL: R17.2, U10.44 (T3CLKO/P0.4), WSL.2
WSR: R18.2, U10.43 (TXD4/P0.3), WSR.2

Notes on the sheet:
左摇杆：油门与航向
右摇杆：横滚与俯仰
无线模块：2.4G插件
无线模块：2.4G贴件

Board: 2 copper layers, 106.5 x 106.1 mm, 119 parts (35 on the bottom side), 98 nets.

## Commit log

2016-12-07 intial commit
2016-12-07 czbd-sch baseline commit

Notices in the files:
parts and their libraries:
SparkFun-PowerIC: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
